<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <group>
      <name>Beep</name>
      <file>
        <name>$PROJ_DIR$\App\Module\Beep\Beep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\Beep\Beep_Hw.c</name>
      </file>
    </group>
    <group>
      <name>BSP</name>
      <file>
        <name>$PROJ_DIR$\App\hw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\stm32f10x_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\system_stm32f10x.c</name>
      </file>
    </group>
    <group>
      <name>Com</name>
      <file>
        <name>$PROJ_DIR$\App\Module\Com\Com.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\Com\Com_Hw.c</name>
      </file>
    </group>
    <group>
      <name>Fan</name>
      <file>
        <name>$PROJ_DIR$\App\Module\Fan\Fan.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\Fan\Fan_Hw.c</name>
      </file>
    </group>
    <group>
      <name>Flash</name>
      <file>
        <name>$PROJ_DIR$\App\Module\Flash\Flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\Flash\Information.c</name>
      </file>
    </group>
    <group>
      <name>Heart</name>
      <file>
        <name>$PROJ_DIR$\App\Module\Heart\Heart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\Heart\Heart_Hw.c</name>
      </file>
    </group>
    <group>
      <name>I2C</name>
      <file>
        <name>$PROJ_DIR$\App\Module\I2C\I2C.c</name>
      </file>
    </group>
    <group>
      <name>Includes</name>
      <group>
        <name>FIFO</name>
        <file>
          <name>$PROJ_DIR$\App\Module\FIFO\FIFO.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\CM3\CoreSupport\core_cm3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\includes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\stm32f10x_conf.h</name>
      </file>
    </group>
    <group>
      <name>Keyboard</name>
      <file>
        <name>$PROJ_DIR$\App\Module\Keyboard\keyboard.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\Keyboard\Keyboard_Hw.c</name>
      </file>
    </group>
    <group>
      <name>LCB</name>
      <file>
        <name>$PROJ_DIR$\App\Module\LCB\LCB.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\LCB\LCB_Hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\LCB\LCB_Hw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\LCB\LCB_Update.c</name>
      </file>
    </group>
    <group>
      <name>Led</name>
      <file>
        <name>$PROJ_DIR$\App\Module\Led\Led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\Led\Led_Hw.c</name>
      </file>
    </group>
    <group>
      <name>Power</name>
      <file>
        <name>$PROJ_DIR$\App\Module\Power\Power.c</name>
      </file>
    </group>
    <group>
      <name>Safekey</name>
      <file>
        <name>$PROJ_DIR$\App\Module\Safekey\Safekey.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\Safekey\Safekey_Hw.c</name>
      </file>
    </group>
    <group>
      <name>System</name>
      <file>
        <name>$PROJ_DIR$\App\Module\System\System.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\System\System_Hw.c</name>
      </file>
    </group>
    <group>
      <name>Timer</name>
      <file>
        <name>$PROJ_DIR$\App\Module\Timer\Timer.c</name>
      </file>
    </group>
    <group>
      <name>TV</name>
      <file>
        <name>$PROJ_DIR$\App\Module\TV\TV.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\App\Module\TV\TV_Hw.c</name>
      </file>
    </group>
    <group>
      <name>WDG</name>
      <file>
        <name>$PROJ_DIR$\App\Module\WatchDog\WatchDog.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\App\main.c</name>
    </file>
  </group>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\Libraries\CMSIS\CM3\CoreSupport\core_cm3.c</name>
    </file>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\startup_stm32f10x_hd.s</name>
    </file>
  </group>
  <group>
    <name>Libraries</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_bkp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_can.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_cec.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_crc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_dbgmcu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_fsmc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_sdio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_tim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\inc\stm32f10x_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c</name>
      </file>
    </group>
  </group>
</project>


