# IAR project Smart Strength.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F101xC ST STM32F101xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ; App\; App\Module\WatchDog; App\Module\I2C; App\Module\Trace; App\Module\Timer; App\Module\Flash; App\Module\FIFO; App\Module\System; App\Module\Beep; App\Module\Safekey; App\Module\LCB; App\Module\RF; App\Module\Update; App\Module\TV; App\Module\Heart; App\Module\Com; App\Module\Keyboard; App\Module\Fan; App\Module\Power; App\Module\Led; Libraries\STM32F10x_StdPeriph_Driver\inc\; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; Libraries\CMSIS\CM3\CoreSupport\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SSA_V2.002.bin
  ILINK.IlinkOutputFile: Smart Strength.out
  ILINK.IlinkIcfFile: Config\Smart Strength.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Smart Strength.srec
  group App
    App/: main.c
  group App/Beep
    App/Module/Beep/: Beep.c Beep_Hw.c
  group App/BSP
    App/: hw.c stm32f10x_it.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group App/Com
    App/Module/Com/: Com.c Com_Hw.c
  group App/Fan
    App/Module/Fan/: Fan.c Fan_Hw.c
  group App/Flash
    App/Module/Flash/: Flash.c Information.c
  group App/Heart
    App/Module/Heart/: Heart.c Heart_Hw.c
  group App/I2C
    App/Module/I2C/: I2C.c
  group App/Includes
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h
    App/: includes.h stm32f10x_conf.h
  group App/Includes/FIFO
    App/Module/FIFO/: FIFO.c
  group App/Keyboard
    App/Module/Keyboard/: keyboard.c Keyboard_Hw.c
  group App/LCB
    App/Module/LCB/: LCB.c LCB_Hal.c LCB_Hw.c LCB_Update.c
  group App/Led
    App/Module/Led/: Led.c Led_Hw.c
  group App/Power
    App/Module/Power/: Power.c
  group App/Safekey
    App/Module/Safekey/: Safekey.c Safekey_Hw.c
  group App/System
    App/Module/System/: System.c System_Hw.c
  group App/Timer
    App/Module/Timer/: Timer.c
  group App/TV
    App/Module/TV/: TV.c TV_Hw.c
  group App/WDG
    App/Module/WatchDog/: WatchDog.c
  group CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group EWARM
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group Libraries/inc
    Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Libraries/src
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
