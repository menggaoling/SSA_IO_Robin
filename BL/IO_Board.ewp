# IAR project IO_Board.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCIncludePath2: library\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; library\CMSIS\CM3\CoreSupport\; library\STM32F10x_StdPeriph_Driver\inc\; Soft\inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: IO_Board.bin
  ILINK.IlinkOutputFile: IO_Board.out
  ILINK.IlinkIcfFile: IO_Board.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: IO_Board.srec
  group (top)
    ./: IO_Board.icf
  group Library
    library/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c
  group Software
    Soft/: cortexm3_macro.s FlashUtility.c main.c stm32f10x_it.c UpdateUart.c
    library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
